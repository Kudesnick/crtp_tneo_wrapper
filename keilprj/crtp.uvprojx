# Keil uVision project crtp.uvprojx, settings and files
target stm32f411 (6190000::V6.19::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: crtp
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=9 wLevel=2
  c define: DEBUG HSE_VALUE=25000000
  c misc: -Wno-c++98-compat -Wno-c++98-compat-pedantic -Wno-padded -Wno-declaration-after-statement
  c include: ..\rtt;..\tneo\src;..\tneo\src\arch;..\tneo\src\arch\cortex_m;..\tneo\src\core;..\tneo\src\core\internal;..\src\os
  asm define: DEBUG
  asm misc: -x assembler-with-cpp
  asm include: ..\tneo\src;..\tneo\src\core;..\src\os
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\src\os\crtp.sct
  group appl
    ../src/appl/: main.cpp
  group os
    ../src/os/: crtp.sct os.h tn_cfg.h
  group rtt
    ../src/rtt/: rtt_io.cpp
    ../rtt/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h
  group tneo
    ../tneo/src/: tn.h
    ../tneo/src/arch/cortex_m/: tn_arch_cortex_m.h tn_arch_cortex_m.S tn_arch_cortex_m_c.c
    ../tneo/src/core/: tn_cfg_dispatch.h tn_common.h tn_common_macros.h tn_dqueue.c tn_dqueue.h tn_eventgrp.c tn_eventgrp.h tn_fmem.c tn_fmem.h tn_list.c tn_list.h tn_mutex.c tn_mutex.h tn_oldsymbols.h tn_sem.c tn_sem.h tn_sys.c tn_sys.h tn_tasks.c tn_tasks.h tn_timer.c tn_timer.h tn_timer_dyn.c tn_timer_static.c
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:Startup 2.6.3
